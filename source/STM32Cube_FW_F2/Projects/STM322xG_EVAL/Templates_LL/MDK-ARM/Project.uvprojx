# Keil uVision project Project.uvprojx, settings and files
target STM322xG-EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F217IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM322xG-EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F217xx,USE_FULL_LL_DRIVER,HSE_VALUE=25000000U
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../../../../Drivers/STM32F2xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Example/User
    ../Src/: main.c stm32f2xx_it.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f217xx.s
  group Drivers/STM32f2xx_LL_Driver
    ../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_ll_exti.c stm32f2xx_ll_usart.c stm32f2xx_ll_dac.c stm32f2xx_ll_gpio.c stm32f2xx_ll_rcc.c stm32f2xx_ll_adc.c stm32f2xx_ll_spi.c stm32f2xx_ll_rng.c stm32f2xx_ll_tim.c stm32f2xx_ll_utils.c stm32f2xx_ll_pwr.c stm32f2xx_ll_crc.c stm32f2xx_ll_i2c.c stm32f2xx_ll_dma.c stm32f2xx_ll_rtc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
software components: CMSIS:CORE 4.3.0
